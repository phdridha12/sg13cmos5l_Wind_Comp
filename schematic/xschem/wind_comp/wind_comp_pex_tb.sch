** sch_path: schematic/xschem/wind_comp/wind_comp_pex_tb.sch
* Copyright 2025 IHP PDK Authors

.include $::PDK_ROOT/ihp-sg13g2/libs.ref/sg13g2_stdcell/spice/sg13g2_stdcell.spice
.include ../../../pex/slot_4.pex.spice
.include @schname.save
.control
op
write @schname.raw
.endc

**.subckt wind_comp_pex_tb
X1 vl vout vh ibias en vin vss vdd slot_4
**** begin user architecture code


.param vdd=1.2 vss=0 vcm=0.6 vrise=0.3
.param vh={vcm+vrise} vl={vcm-vrise}
.param ibias=1u en=1.2 cload=100f rload=1G
.param fin=10k vamp=0.6 tnom=27
.param ac_vdd=0 ac_vss=0
.temp {tnom}
.option method=gear
.option savecurrents
.option filetype=ascii
.option color0=white
.option color1=black
.option hcopydevtype=svg
Vdd vdd 0 dc {vdd} ac {ac_vdd}
Vvh vh 0 dc {vh}
Cload vout 0 {cload}
Rload vout vss {rload}
Vvl vl 0 dc {vl}
Ibias vdd ibias dc {ibias}
Vss vss 0 dc {vss} ac {ac_vss}
Ven en 0 dc {en}




**nr_workers=8
**nr_mc_sims=200
**pvt_process = mos_tt_stat
**pvt_temp = 27
**pvt_vdd = 1.2

**results_plot_begin
**vth_l [V]
**vth_h [V]
**vos_l [V], <-20m, >20m
**vos_h [V], <-20m, >20m
**win_w [V]
**pstat [W], >30u
**results_plot_end





.lib cornerMOSlv.lib mos_tt_stat
.lib cornerMOShv.lib mos_tt_stat
.lib cornerMOSCAP.lib moscap_tt
.lib cornerCAP.lib cap_typ
.lib cornerRES.lib res_typ
.lib cornerDIO.lib dio_tt





Vin vin 0 dc {vcm}
.control
save v(vin) v(vout) v(vdd) v(vl) v(vh) i(vdd)
op
let pstat = -i(Vdd) * v(vdd)
let vdd_op = v(vdd)
let vmid_op = v(vdd) / 2
let vl_op = v(vl)
let vh_op = v(vh)
set pstat_val = $&pstat
set vdd_val = $&vdd_op
set vmid_val = $&vmid_op
set vl_val = $&vl_op
set vh_val = $&vh_op

dc Vin 0 $vdd_val 2m
meas dc vth_l WHEN v(vout)=$vmid_val RISE=1
meas dc vth_h WHEN v(vout)=$vmid_val FALL=1
let vos_l = vth_l - $vl_val
let vos_h = vth_h - $vh_val
let win_w = vth_h - vth_l

echo results_save_begin
echo vth_l = $&vth_l
echo vth_h = $&vth_h
echo vos_l = $&vos_l
echo vos_h = $&vos_h
echo win_w = $&win_w
echo pstat = $pstat_val
echo results_save_end
.endc


**** end user architecture code
**.ends
.end
